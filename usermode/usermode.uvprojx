# Keil uVision project usermode.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: usermode
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x1000000 size 0x10000
  memory RVCT5: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x21000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.1
